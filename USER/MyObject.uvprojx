# Keil uVision project MyObject.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyObject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MyObject
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\LIB\break;..\LIB\fdc2x14;..\LIB\key;..\LIB\iic;..\LIB\led;..\LIB\pid;..\LIB\motor;..\LIB\lcd;..\LIB\DataScope_DP;..\BSP\pretreat;..\BSP\display
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c headers.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c usart.h
  group LIB
    ../LIB/fdc2x14/: FDC2X14.c FDC2X14.h
    ../LIB/iic/: myiic.c myiic.h myiic2.c myiic2.h
    ../LIB/led/: led.c led.h
    ../LIB/pid/: pid.c pid.h
    ../LIB/motor/: motor.c motor.h
    ../LIB/break/: break.c break.h
    ../LIB/lcd/: lcd.c lcd.h stm32f10x_fsmc.c stm32f10x_fsmc.h
    ../LIB/key/: key.c key.h
    ../LIB/DataScope_DP/: DataScope_DP.C DataScope_DP.h
  group BSP
    ../BSP/pretreat/: pretreat.c pretreat.h
    ../BSP/display/: display.c display.h
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
